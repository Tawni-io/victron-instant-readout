#include "ui/text.h"

namespace {

constexpr int kGlyphW = 8;
constexpr int kGlyphH = 12;
constexpr int kGlyphGap = 1;

// 8x12 glyphs, bit7 = leftmost column. Rows top→bottom.
// Designed for dash readability (thicker strokes than classic 5x7).
const uint8_t FONT[][kGlyphH] = {
    // 0-9
    {0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0x18, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x00},
    {0x3C, 0x66, 0xC3, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0x00},
    {0x3C, 0x66, 0xC3, 0x03, 0x03, 0x1E, 0x03, 0x03, 0xC3, 0x66, 0x3C, 0x00},
    {0x06, 0x0E, 0x1E, 0x36, 0x66, 0xC6, 0xFF, 0x06, 0x06, 0x06, 0x06, 0x00},
    {0xFF, 0xC0, 0xC0, 0xC0, 0xFC, 0x06, 0x03, 0x03, 0xC3, 0x66, 0x3C, 0x00},
    {0x1C, 0x30, 0x60, 0xC0, 0xFC, 0xE6, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0xFF, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00},
    {0x3C, 0x66, 0xC3, 0xC3, 0x66, 0x3C, 0x66, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0x67, 0x3F, 0x03, 0x06, 0x0C, 0x38, 0x00},
    // . - space
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    // A-Z
    {0x18, 0x3C, 0x66, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00},
    {0xFE, 0xC3, 0xC3, 0xC3, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x00},
    {0x3C, 0x66, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0x66, 0x3C, 0x00},
    {0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0x00},
    {0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x00},
    {0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00},
    {0x3C, 0x66, 0xC3, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x67, 0x3D, 0x00},
    {0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00},
    {0x7E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x00},
    {0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0xC3, 0xC6, 0xCC, 0xD8, 0xF0, 0xE0, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0x00},
    {0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x00},
    {0xC3, 0xE7, 0xFF, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00},
    {0xC3, 0xE3, 0xF3, 0xDB, 0xCF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00},
    {0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0xFE, 0xC3, 0xC3, 0xC3, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00},
    {0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xDB, 0xCF, 0x66, 0x3D, 0x00},
    {0xFE, 0xC3, 0xC3, 0xC3, 0xFE, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xC3, 0x00},
    {0x3C, 0x66, 0xC3, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC3, 0x66, 0x3C, 0x00},
    {0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00},
    {0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x00},
    {0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x18, 0x18, 0x00},
    {0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xDB, 0xDB, 0xFF, 0xE7, 0xC3, 0xC3, 0x00},
    {0xC3, 0xC3, 0x66, 0x3C, 0x18, 0x18, 0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0x00},
    {0xC3, 0xC3, 0x66, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00},
    {0xFF, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC0, 0xC0, 0xFF, 0x00},
    // %  (two circles + slash — not a degree mark)
    {0x62, 0x96, 0x94, 0x68, 0x08, 0x10, 0x10, 0x16, 0x29, 0x69, 0x46, 0x00},
    // + : /
    {0x00, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00},
    {0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x00},
};

int glyph_index(char c) {
  if (c >= '0' && c <= '9') return c - '0';
  if (c == '.') return 10;
  if (c == '-') return 11;
  if (c == ' ') return 12;
  if (c >= 'A' && c <= 'Z') return 13 + (c - 'A');
  if (c >= 'a' && c <= 'z') return 13 + (c - 'a');
  if (c == '%') return 39;
  if (c == '+') return 40;
  if (c == ':') return 41;
  if (c == '/') return 42;
  return 12;
}

void draw_glyph(int x, int y, int gi, uint16_t fg, uint16_t bg, int scale) {
  if (gi < 0) return;
  for (int row = 0; row < kGlyphH; row++) {
    const uint8_t bits = FONT[gi][row];
    for (int col = 0; col < kGlyphW; col++) {
      const bool on = (bits & (0x80 >> col)) != 0;
      const uint16_t color = on ? fg : bg;
      if (scale <= 1) {
        if (on || bg != fg) {
          display_fill_rect(x + col, y + row, 1, 1, color);
        }
      } else {
        display_fill_rect(x + col * scale, y + row * scale, scale, scale, color);
      }
    }
  }
}

}  // namespace

int text_height(int scale) {
  if (scale < 1) scale = 1;
  if (scale > 3) scale = 3;
  return kGlyphH * scale;
}

int text_width(const char* s, int scale) {
  if (!s || scale < 1) return 0;
  if (scale > 3) scale = 3;
  int n = 0;
  while (*s++) n++;
  if (n == 0) return 0;
  return n * (kGlyphW * scale) + (n - 1) * (kGlyphGap * scale);
}

void text_draw(int x, int y, const char* s, uint16_t fg, uint16_t bg, int scale) {
  if (!s || scale < 1) return;
  if (scale > 3) scale = 3;
  int cx = x;
  while (*s) {
    draw_glyph(cx, y, glyph_index(*s), fg, bg, scale);
    cx += kGlyphW * scale + kGlyphGap * scale;
    s++;
  }
}
